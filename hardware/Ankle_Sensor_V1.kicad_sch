File: hardware/Ankle_Sensor_V1.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: update
Other:
- title: Ankle Sensor V1 - WORK IN PROGRESS -> Ankle Sensor V1 - AUDIT REVIEW
